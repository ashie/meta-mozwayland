CORE_IMAGE_BASE_INSTALL += "adwaita-icon-theme adwaita-icon-theme-cursors"
